## FreeRTOS/blink/sdkconfig.defaults.esp32c6
```kconfig
CONFIG_BLINK_LED_STRIP=y

CONFIG_COMPILER_OPTIMIZATION_DEFAULT=y
CONFIG_COMPILER_OPTIMIZATION_DEBUG=y
```
